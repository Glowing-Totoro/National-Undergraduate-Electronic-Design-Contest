# Keil uVision project atk_f103.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Middlewares;..\..\Middlewares\oled;..\..\Control\Show_oled;..\..\mpu6050\DMP;..\..\mpu6050\filter;..\..\mpu6050\IIC;..\..\mpu6050\MPU6050;..\..\mpu6050\Inc;..\..\Control;..\..\Middlewares\ccd;..\..\Middlewares\motor;..\..\Middlewares\encoder;..\..\Control\PID;..\..\Control\CCD;..\..\Control\OPENMV;..\..\Control\Contanct;..\..\Middlewares\Servo;..\..\Control\Task
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../Users/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/EXTI/: exti.c
    ../../Drivers/BSP/TIMER/: generaltimer.c
    ../../Drivers/BSP/GPIO/: gpio.c
    ../../Drivers/BSP/ADC/: adc.c
  group Middlewares
    ../../Middlewares/oled/: bsp_oled.c
    ../../Middlewares/Servo/: bsp_servo.c
  group Control
    ../../Control/Show_oled/: show.c
    ../../Control/: control.c
    ../../Control/PID/: pid.c
    ../../Control/OPENMV/: openmv.c
    ../../Control/Task/: Task.c
  group Readme
    ../../: Readme.md
